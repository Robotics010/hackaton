Commit message: bringup split robot to blue and yellow

File: modules/bringup/simulator_bringup/urdf/yellow.urdf (robot description, URDF)
Before this commit: robot big_robotic, 4 links, 3 joints
Links:
- link catch_footprint_link: geometry visual cylinder length=0.04 radius=${catch_radius}
